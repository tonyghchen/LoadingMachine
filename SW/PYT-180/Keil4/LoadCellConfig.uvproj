# Keil uVision project LoadCellConfig.uvproj, settings and files
target TIMER_Periodic (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: TIMER_Periodic
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 wLevel=2
  c define: TRACE_MODE=0
  c include: ..\Library\Device\Nuvoton\M480\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc;.\PRO;.\uty;.\uty\PRO;.\EtherCat\inc;.\SeggerView\src\Config;.\SeggerView\src\SEGGER
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../src/: modbus_bsq_dg.cpp modbus.cpp
    ../src/LoadCellConfig/: main_LoadCellConfig.cpp uart_transfer.c
  group Library
    ../Library/StdDriver/src/: clk.c sys.c uart.c timer.c ebi.c gpio.c retarget.c crc.c pdma.c qspi.c
target Timer_Periodic_RTT (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: as above
  output: PYT-1320
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\cnc1320.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 wLevel=2
  c define: TRACE_MODE=2
  c include: ..\inc;..\PRO;..\uty;..\uty\PRO;..\EtherCat\inc;..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M480\Include;..\Library\StdDriver\inc;..\Library\SeggerView\src\Config;..\Library\SeggerView\src\SEGGER
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: as above
